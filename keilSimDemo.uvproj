# Keil uVision project keilSimDemo.uvproj, settings and files
target debug (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keilSimDemo +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 main.c ecc.c
